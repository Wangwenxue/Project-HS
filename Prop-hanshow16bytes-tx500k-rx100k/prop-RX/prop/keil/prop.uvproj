# Keil uVision project prop.uvproj, settings and files
target prop (ARM-ADS)
  device: QN9020 Quintic
  cpu: IRAM(0x10008000-0x1000FFFF) IROM(0x10000000-0x10007FFF) CLOCK(16000000) CPUTYPE("Cortex-M0")
  output: prop
  AfterMake: fromelf --bin --output ./bin/prop.bin ./obj/prop.axf
  c flags: Optim=1 OneElfS=1
  c misc: --C99
  c include: ..\src;..\..\src\driver;..\..\src\fw;..\..\src\cmsis;..\..\src\lib
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x10008000 size 0x8000
  scatter file: ..\..\src\link\keil\qn9020_link.sct
  group startup
    ../../src/startup/keil/: startup.s
  group system
    ../src/: system.c
  group driver
    ../../src/driver/: adc.c analog.c dma.c gpio.c i2c.c pwm.c rtc.c serialflash.c sleep.c spi.c syscon.c timer.c uart.c wdt.c
  group lib
    ../../src/lib/keil/: qn902xb2_lib_lite.lib
  group retarget
    ../../src/retarget/: retarget.c
  group main
    ../src/: prop_example.c proprietary.c crc.c expandbits.c
